# Keil uVision project openloop.uvprojx, settings and files
target STM32H743 (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: openloop
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Hardware
    ../2_openloop/Hardware/: delay.c timer.c usart.c
  group SimpleFOC
    ./SimpleFOC/: BLDCMotor.c foc_utils.c FOCMotor.c
  group User
    ./user/: main.c MyProject.h stm32h7xx_it.c stm32h7xx_it.h
  group startup
    ./startup/: core_cm7.h startup_stm32h743xx.s stm32h7xx.h system_stm32h7xx.c system_stm32h7xx.h system_stm32h7xx_dualcore_boot_cm4_cm7.c system_stm32h7xx_dualcore_bootcm4_cm7gated.c system_stm32h7xx_dualcore_bootcm7_cm4gated.c system_stm32h7xx_singlecore.c
